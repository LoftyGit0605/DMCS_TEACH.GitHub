# Keil uVision project LPC1788_DMCS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1778 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1788_DMCS
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c include: .\LIB;.\APP;.\StartUp;.\LIB\include
  memory RVCT4: ROM 0x18000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --libpath=C:\Keil\ARM\ARMCC\lib
  group StartUp
    ./StartUp/: startup_LPC177x_8x.s system_LPC177x_8x.c
  group LIB
    ./LIB/: LPC1788_DMCS.lib
  group APP
    ./APP/: main.c Public.c UserFunc.c UserCrc.c
